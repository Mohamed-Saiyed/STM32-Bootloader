# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c gpio_driver.c gpio_driver.h hal_uart_driver.c hal_uart_driver.h hal_DMA_driver.h hal_DMA_driver.c led.c led.h hal_crc_driver.c hal_crc_driver.h main.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
